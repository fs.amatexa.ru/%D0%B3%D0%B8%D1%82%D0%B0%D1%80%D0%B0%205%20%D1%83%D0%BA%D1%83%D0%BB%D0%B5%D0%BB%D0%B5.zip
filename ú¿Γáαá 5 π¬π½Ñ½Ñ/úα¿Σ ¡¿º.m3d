# KOMPAS-3D part (úα¿Σ ¡¿º.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 108
3. Скругление:1
     Радиус = 11
4. Скругление:2
     Радиус = 11
