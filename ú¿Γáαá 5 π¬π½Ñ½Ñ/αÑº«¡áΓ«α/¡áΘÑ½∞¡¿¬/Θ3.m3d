# KOMPAS-3D part (Θ3.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 2
3. Скругление:1
     Радиус = 2
4. Скругление:2
     Радиус = 2
